## boards/shields/nrfvoltex/Kconfig.defconfig
```kconfig
if SHIELD_NRFVOLTEX

config ZMK_KEYBOARD_NAME
    default "nRFVoltex"

endif # SHIELD_NRFVOLTEX
```
